# Keil uVision project Final_Project.uvprojx, settings and files
target ECE353_FinalProject (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include;..\drivers\include;..\peripherals\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c images.c images.h main.h alphabet.c alphabet.h hw1.s game.h game.c buttons.c buttons.h ioexpander.c
    ../HW1/: hw1_ws2812b.s
  group drivers headers
    ../drivers/include/: adc.h driver_defines.h gpio_port.h i2c.h interrupts.h pc_buffer.h spi.h timers.h uart.h
  group Lib
    ../lib/: hw2_f18.lib ECE353-Validate.lib
  group periph source
    ../peripherals/c/: accel.c ece353_images.c eeprom.c ft6x06.c launchpad_io.c lcd.c lcd_images.c ps2.c serial_debug.c spi_select.c ws2812b_ice.c wireless.c
  group periph headers
    ../peripherals/include/: accel.h ece353_images.h eeprom.h ft6x06.h io_expander.h launchpad_io.h lcd.h lcd_images.h ps2.h serial_debug.h spi_select.h validate.h wireless.h ws2812b.h ws2812b_effects.h
  group drivers source
    ../drivers/c/: adc.c gpio_port.c i2c.c pc_buffer.c spi.c timers.c uart.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
