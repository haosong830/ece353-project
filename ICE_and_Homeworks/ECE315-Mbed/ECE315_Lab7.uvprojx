# Keil uVision project ECE315_Lab7.uvprojx, settings and files
target ECE315_Lab7 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303K8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: ECE315_blink_led
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=4 v6LangP=2
  c define: DEVICE_RTC=1 DEVICE_SLEEP=1 MBED_BUILD_TIMESTAMP=1547483078.68 RTC_LSI=1 __ASSERT_MSG TARGET_RELEASE DEVICE_PORTINOUT=1 DEVICE_PWMOUT=1 DEVICE_I2C_ASYNCH=1 TARGET_FF_ARDUINO TARGET_RTOS_M4_M7 DEVICE_CAN=1 DEVICE_PORTOUT=1 DEVICE_STDIO_MESSAGES=1 DEVICE_ANALOGOUT=1 TARGET_LIKE_MBED DEVICE_SERIAL_FC=1 DEVICE_SERIAL=1 DEVICE_ANALOGIN=1 TARGET_LIKE_CORTEX_M4 TARGET_CORTEX_M TARGET_NUCLEO_F303K8 ARM_MATH_CM4 DEVICE_I2C=1 __CORTEX_M4 TARGET_CORTEX DEVICE_LOWPOWERTIMER=1 TARGET_STM32F303K8 TOOLCHAIN_ARM DEVICE_INTERRUPTIN=1 TOOLCHAIN_ARM_STD TARGET_STM32F303x8 TARGET_STM TARGET_FAMILY_STM32 DEVICE_SPI=1 __MBED__=1 DEVICE_SPISLAVE=1 DEVICE_PORTIN=1 TARGET_M4 __FPU_PRESENT=1 DEVICE_I2CSLAVE=1 __CMSIS_RTOS DEVICE_SPI_ASYNCH=1 TRANSACTION_QUEUE_SIZE_SPI=2 __MBED_CMSIS_RTOS_CM TARGET_STM32F3
  c misc: --no_rtti --split_sections -c --cpu=Cortex-M4.fp --no_depend_system_headers --md --gnu --apcs=interwork --preinclude=mbed_config.h
  c include: .;mbed;mbed/TARGET_NUCLEO_F303K8;mbed/TARGET_NUCLEO_F303K8/TARGET_STM;mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3;mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8;mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8/TARGET_NUCLEO_F303K8;mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8/device;mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/device;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DRTC_LSI=1,-D__CORTEX_M4,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .\mbed\TARGET_NUCLEO_F303K8\TOOLCHAIN_ARM_STD\stm32f303x8.sct
  link misc: --show_full_path
  group ECE315_Lab7
    ./: main.cpp mbed_config.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o analogout_device.o can_api.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o mbed_sdk_boot.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o serial_device.o sleep.o spi_api.o startup_stm32f303x8.o stm32f3xx_hal.o stm32f3xx_hal_adc.o stm32f3xx_hal_adc_ex.o stm32f3xx_hal_can.o stm32f3xx_hal_cec.o stm32f3xx_hal_comp.o stm32f3xx_hal_cortex.o stm32f3xx_hal_crc.o stm32f3xx_hal_crc_ex.o stm32f3xx_hal_dac.o stm32f3xx_hal_dac_ex.o stm32f3xx_hal_dma.o stm32f3xx_hal_flash.o stm32f3xx_hal_flash_ex.o stm32f3xx_hal_gpio.o stm32f3xx_hal_hrtim.o stm32f3xx_hal_i2c.o stm32f3xx_hal_i2c_ex.o stm32f3xx_hal_i2s.o stm32f3xx_hal_i2s_ex.o stm32f3xx_hal_irda.o stm32f3xx_hal_iwdg.o stm32f3xx_hal_nand.o stm32f3xx_hal_nor.o stm32f3xx_hal_opamp.o stm32f3xx_hal_opamp_ex.o stm32f3xx_hal_pccard.o stm32f3xx_hal_pcd.o stm32f3xx_hal_pcd_ex.o stm32f3xx_hal_pwr.o stm32f3xx_hal_pwr_ex.o stm32f3xx_hal_rcc.o stm32f3xx_hal_rcc_ex.o stm32f3xx_hal_rtc.o stm32f3xx_hal_rtc_ex.o stm32f3xx_hal_sdadc.o stm32f3xx_hal_smartcard.o stm32f3xx_hal_smartcard_ex.o stm32f3xx_hal_smbus.o stm32f3xx_hal_spi.o stm32f3xx_hal_spi_ex.o stm32f3xx_hal_sram.o stm32f3xx_hal_tim.o stm32f3xx_hal_tim_ex.o stm32f3xx_hal_tsc.o stm32f3xx_hal_uart.o stm32f3xx_hal_uart_ex.o stm32f3xx_hal_usart.o stm32f3xx_hal_wwdg.o stm32f3xx_ll_adc.o stm32f3xx_ll_comp.o stm32f3xx_ll_crc.o stm32f3xx_ll_dac.o stm32f3xx_ll_dma.o stm32f3xx_ll_exti.o stm32f3xx_ll_fmc.o stm32f3xx_ll_gpio.o stm32f3xx_ll_hrtim.o stm32f3xx_ll_i2c.o stm32f3xx_ll_opamp.o stm32f3xx_ll_pwr.o stm32f3xx_ll_rcc.o stm32f3xx_ll_rtc.o stm32f3xx_ll_spi.o stm32f3xx_ll_tim.o stm32f3xx_ll_usart.o stm32f3xx_ll_utils.o stm_spi_api.o sys.o system_clock.o system_stm32f3xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o
    mbed/TARGET_NUCLEO_F303K8/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/: can_device.h common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h spi_device.h
    mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32f303x8.h stm32f3xx.h system_stm32f3xx.h
    mbed/TARGET_NUCLEO_F303K8/TARGET_STM/: gpio_object.h mbed_rtx.h nvic_addr.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h serial_api_hal.h stm32_assert.h
    mbed/: mbed.h
    mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8/: objects.h
    mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8/TARGET_NUCLEO_F303K8/: PeripheralNames.h PinNames.h
    mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/device/: stm32_hal_legacy.h stm32f3xx_hal.h stm32f3xx_hal_adc.h stm32f3xx_hal_adc_ex.h stm32f3xx_hal_can.h stm32f3xx_hal_cec.h stm32f3xx_hal_comp.h stm32f3xx_hal_comp_ex.h stm32f3xx_hal_conf.h stm32f3xx_hal_cortex.h stm32f3xx_hal_crc.h stm32f3xx_hal_crc_ex.h stm32f3xx_hal_dac.h stm32f3xx_hal_dac_ex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_hrtim.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_i2s.h stm32f3xx_hal_i2s_ex.h stm32f3xx_hal_irda.h stm32f3xx_hal_irda_ex.h stm32f3xx_hal_iwdg.h stm32f3xx_hal_nand.h stm32f3xx_hal_nor.h stm32f3xx_hal_opamp.h stm32f3xx_hal_opamp_ex.h stm32f3xx_hal_pccard.h stm32f3xx_hal_pcd.h stm32f3xx_hal_pcd_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_hal_rtc.h stm32f3xx_hal_rtc_ex.h stm32f3xx_hal_sdadc.h stm32f3xx_hal_smartcard.h stm32f3xx_hal_smartcard_ex.h stm32f3xx_hal_smbus.h stm32f3xx_hal_spi.h stm32f3xx_hal_spi_ex.h stm32f3xx_hal_sram.h stm32f3xx_hal_tim.h stm32f3xx_hal_tim_ex.h stm32f3xx_hal_tsc.h stm32f3xx_hal_uart.h stm32f3xx_hal_uart_ex.h stm32f3xx_hal_usart.h stm32f3xx_hal_usart_ex.h stm32f3xx_hal_wwdg.h stm32f3xx_ll_adc.h stm32f3xx_ll_bus.h stm32f3xx_ll_comp.h stm32f3xx_ll_cortex.h stm32f3xx_ll_crc.h stm32f3xx_ll_dac.h stm32f3xx_ll_dma.h stm32f3xx_ll_exti.h stm32f3xx_ll_fmc.h stm32f3xx_ll_gpio.h stm32f3xx_ll_hrtim.h stm32f3xx_ll_i2c.h stm32f3xx_ll_iwdg.h stm32f3xx_ll_opamp.h stm32f3xx_ll_pwr.h stm32f3xx_ll_rcc.h stm32f3xx_ll_rtc.h stm32f3xx_ll_spi.h stm32f3xx_ll_system.h stm32f3xx_ll_tim.h stm32f3xx_ll_usart.h stm32f3xx_ll_utils.h stm32f3xx_ll_wwdg.h
